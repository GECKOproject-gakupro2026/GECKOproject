<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\B-U585I-IOT02A_NS.ewp</path>
  </project><project>
    <path>$WS_DIR$\B-U585I-IOT02A_S.ewp</path>
  </project>
  <batchBuild />
</workspace>
