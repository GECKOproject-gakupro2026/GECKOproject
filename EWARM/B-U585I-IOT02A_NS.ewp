# IAR project B-U585I-IOT02A_NS.ewp, settings and files
configuration B-U585I-IOT02A_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../NonSecure/LPBAM/LpbamAp1; ../Secure_nsclib; ../NonSecure/Core/Inc; ../Utilities/lpbam; ../Utilities/lpbam/STM32U5; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B-U585I-IOT02A_NS.hex
  ILINK.IlinkOutputFile: B-U585I-IOT02A_NS.out
  ILINK.IlinkIcfFile: stm32u585xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User/NonSecure/Core
    ../NonSecure/Core/Src/: main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Application/User/NonSecure/LPBAM/LpbamAp1
    ../NonSecure/LPBAM/LpbamAp1/: lpbam_lpbamap1_config.c lpbam_lpbamap1_scenario_build.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_ll_utils.c stm32u5xx_ll_exti.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_ramcfg.c
  group Drivers/CMSIS
    ../NonSecure/Core/Src/: system_stm32u5xx_ns.c
  group Utilities
    ../Utilities/lpbam/: stm32_adv_lpbam_common.c stm32_lpbam_common.c
    ../Utilities/lpbam/STM32U5/: stm32_ll_lpbam.c
